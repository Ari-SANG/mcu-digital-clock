# Keil uVision project Uart1_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Uart1_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;.\Application;.\Drivers
  group Application
    ./: main.c
    ./Application/: app.c
  group Drivers
    ./Drivers/: board.c keys.c uart1.c
  group Headers
    ./: config.h
    ./Application/: app.h
    ./Drivers/: board.h keys.h uart1.h
